Commit message: week 2

File: Basics of pyBullet/Week 2/Subpart 3/sphere.urdf (robot description, URDF)
Before this commit: robot sphere, 1 links, 0 joints
Links:
- link base: mass 20 -> 0.1
